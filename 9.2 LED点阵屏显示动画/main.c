#include <REGX52.H>
#include "Delay.h"
#include "MatrixLED.h"


//unsigned char MatrixLED[]={
//	0x00,0x00,0xFE,0x10,0x10,0x10,0xFE,0x00,
//	0x1C,0x2A,0x2A,0x2A,0x18,0x00,0xFE,0x02,
//	0x04,0x00,0xFE,0x02,0x04,0x00,0x1C,0x22,
//	0x22,0x22,0x1C,0x00,0x00,0x00,0x00,0x00,
//	0x00,0x00,};//每列所要显示的数据（Hello！）

//unsigned char i,Offset,Count;

//void main()		//动画流动显示Hello!
//{
//	while(1)
//	{
//		for(i=0;i<8;i++)		//LED点阵屏不断扫描，显示数据
//		{
//			MatrixLED_Show(i,MatrixLED[i+Offset]);
//		}
//		Count++;				//扫描完一遍后计次
//		if(Count>10)			//计到10个后清零，并开始偏移
//		{
//			Count=0;
//			Offset++;
//			if(Offset>26)		//偏移到最大值后清零，重复最开始的动画
//			{
//				Offset=0;
//			}
//		}
//	}
//}

/*-------------------------------------------------------------------------------------------*/

//unsigned char MatrixLED[]={
//	0x3C,0x42,0xA9,0x85,0x85,0xA9,0x42,0x3C,
//	0x3C,0x42,0xA1,0x85,0x85,0xA1,0x42,0x3C,
//	0x3C,0x42,0xA5,0x89,0x89,0xA5,0x42,0x3C,};//动画帧，8个一组，笑脸、哭脸与平常

unsigned char MatrixLED[]={
	0x00,0x00,0x1B,0x3C,0xF8,0xFC,0x3B,0x00,0x00,0x1B,0x3C,0xFC,0xFF,0x3A,0x00,0x00,
	0x00,0x00,0x0B,0x1C,0x7C,0x7E,0x1B,0x00,0x00,0x1B,0x3C,0xFC,0xFF,0x3A,0x00,0x00,};//动画帧，鸡哥铁山靠，四帧动画

unsigned char i,Offset,Count;

void main()		//动画显示笑脸、哭脸、平常脸，8个为一帧一起变
{
	while(1)
	{
		for(i=0;i<8;i++)		//LED点阵屏不断扫描，显示数据
		{
			MatrixLED_Show(i,MatrixLED[i+Offset]);
		}
		Count++;				//扫描完一遍后计次
		if(Count>10)			//计到10个后清零，并开始偏移
		{
			Count=0;
			Offset+=8;
			if(Offset>16)		//偏移到最大值后清零，重复最开始的动画
			{
				Offset=0;
			}
		}
	}
}

